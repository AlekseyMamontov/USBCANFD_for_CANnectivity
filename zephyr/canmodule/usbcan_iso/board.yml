## zephyr/canmodule/usbcan_iso/board.yml
```yaml
board:
  name: usbcan_iso
  full_name: USBCAN_Iso (can-module.com)
  vendor: st
  socs:
    - name: stm32f072xb
```
